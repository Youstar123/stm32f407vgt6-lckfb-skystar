# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, STM32F407xx, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_LIBC
  c include: board\CubeMX_Config\Inc;rt-thread\components\finsh;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\smp_call;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\eventfd;applications;libraries\HAL_Drivers;.;rt-thread\libcpu\arm\cortex-m4;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\include;libraries\HAL_Drivers\drivers\config;libraries\HAL_Drivers\drivers;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\phy;rt-thread\components\libc\posix\io\epoll;board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    build/board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Finsh
    rt-thread/components/finsh/: msh.c shell.c cmd.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstdio.c kstring.c rt_vsscanf.c kerrno.c rt_vsnprintf_tiny.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_cec.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cryp.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
